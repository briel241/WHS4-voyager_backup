options:
  parameters:
    author: voyager_3
    description: VDE-TER stage 2 link-layer transmitter using the existing BPSK PHY and a VDE TX Adapter
    generate_options: qt_gui
    id: vdeter_tx
    output_language: python
    title: VDE-TER Stage 2 Transmitter - Type 92/93 over BPSK (Node A)
  states: {}

blocks:
- name: bpsk
  id: variable_constellation
  parameters:
    comment: BPSK constellation shared by the transmitter and receiver
    const_points: '[-1, 1]'
    precision: '8'
    rot_sym: '2'
    sym_map: '[0, 1]'
    type: bpsk
  states: {}
- name: center_freq
  id: variable
  parameters:
    comment: Using 1 GHz is possible but increases the observed frequency error
    value: 157.2e6
  states: {}
- name: excess_bw
  id: variable
  parameters:
    comment: RRC roll-off factor
    value: '0.35'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    comment: Sample rate
    value: 1e6
  states: {}
- name: sps
  id: variable
  parameters:
    comment: Samples per symbol; symbol rate is 250 ksym/s
    value: '4'
  states: {}
- name: tx_ampl
  id: variable
  parameters:
    comment: Amplitude relative to DAC full scale
    value: '0.5'
  states: {}
- name: tx_dev
  id: variable
  parameters:
    comment: Transmit device
    value: '''type=b200'''
  states: {}
- name: tx_gain
  id: variable
  parameters:
    comment: Measured operating value; increase this first if needed
    value: '40'
  states: {}
- name: amp
  id: blocks_multiply_const_vxx
  parameters:
    const: tx_ampl
    type: complex
  states: {}
- name: modulator
  id: digital_constellation_modulator
  parameters:
    comment: Unpacks bytes MSB-first, applies differential BPSK, and performs RRC shaping
    constellation: bpsk
    differential: 'True'
    excess_bw: excess_bw
    samples_per_symbol: sps
  states: {}
- name: vde_tx_adapter
  id: epy_block
  parameters:
    _source_code: |
      # Thin GRC entry-point wrapper for the VDE TX Adapter.
      # VDETxSource in vdeter/radio/gnuradio_tx.py provides the implementation.
      # Message, Packet, and Burst logic is not duplicated here.
      import os
      import sys

      try:
          _base = os.path.dirname(os.path.abspath(__file__))
      except NameError:
          # __file__ is unavailable when GRC evaluates the code without a generated file.
          _base = os.path.abspath(os.getcwd())

      # Locate the src-layout vdeter package independently of the launch directory.
      _probe = _base
      while True:
          _src = os.path.join(_probe, 'src')
          if os.path.isfile(os.path.join(_src, 'vdeter', '__init__.py')):
              if _src not in sys.path:
                  sys.path.insert(0, _src)
              break
          _parent = os.path.dirname(_probe)
          if _parent == _probe:
              break
          _probe = _parent

      from vdeter.radio import gnuradio_tx


      class blk(gnuradio_tx.VDETxSource):
          """Transmit fixed or interactive requests as Temporary Burst bytes."""

          def __init__(self):
              super().__init__()
    comment: VDETxSource from vdeter/radio/gnuradio_tx.py
  states: {}
- name: readme
  id: note
  parameters:
    note: |-
      VDE-TER Stage 2 Transmitter (Node A) - Type 92/93 link layer over the existing BPSK PHY

      VDE TX Adapter : Accepts terminal requests or config.py TX_MESSAGES, encodes each Type,
                       and outputs [F9A8 | Temporary Packet Length | VDE Packet] bytes
      Const Modulator: Unpacks bytes MSB-first and applies differential BPSK with RRC shaping
      Multiply Const : Adjusts the digital signal amplitude
      USRP Sink      : Transmits the RF signal

      TX_MODE='interactive': enter Message count, Type, Payload, and repeat count in the terminal.
      TX_MODE='fixed': use TX_MESSAGES and TX_REPEAT_COUNT in vdeter/link/config.py.
      Repeat count applies to the complete Burst, not to individual Messages.

      Run only through the TX/RX - 30 dB attenuator - coaxial cable - RX2 path without antennas.
      Receiver: vdeter_rx.grc   Specifications: requirements.md / grc_block_configuration.md
  states: {}
- name: tx_spectrum
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    average: '0.2'
    bw: samp_rate
    comment: Displays the transmitted spectrum
    fc: '0'
    fftsize: '2048'
    grid: 'True'
    name: Transmit Spectrum
    tr_tag: ''
    type: complex
    update_time: '0.1'
  states: {}
- name: usrp_sink
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    center_freq0: center_freq
    comment: Run only through a coaxial cable and attenuator without antennas
    dev_addr: tx_dev
    gain0: tx_gain
    len_tag_name: ''
    samp_rate: samp_rate
    start_time: '-1'
    sync: sync
    type: fc32
  states: {}

connections:
- [amp, '0', tx_spectrum, '0']
- [amp, '0', usrp_sink, '0']
- [modulator, '0', amp, '0']
- [vde_tx_adapter, '0', modulator, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
