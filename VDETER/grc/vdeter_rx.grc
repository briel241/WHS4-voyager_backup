options:
  parameters:
    author: voyager_3
    description: VDE-TER stage 2 link-layer receiver using the existing F9A8 BPSK PHY and a VDE RX Adapter
    generate_options: qt_gui
    id: vdeter_rx
    output_language: python
    title: VDE-TER Stage 2 Receiver - Type 92/93 over BPSK (Node B)
  states: {}

blocks:
- name: bpsk
  id: variable_constellation
  parameters:
    comment: BPSK constellation shared by the transmitter and receiver
    const_points: '[-1, 1]'
    precision: '8'
    rot_sym: '2'
    sym_map: '[0, 1]'
    type: bpsk
  states: {}
- name: center_freq
  id: variable
  parameters:
    comment: Using 1 GHz is possible but increases the observed frequency error
    value: 157.2e6
  states: {}
- name: excess_bw
  id: variable
  parameters:
    comment: RRC roll-off factor
    value: '0.35'
  states: {}
- name: rx_dev
  id: variable
  parameters:
    comment: Receive device
    value: '''type=b200'''
  states: {}
- name: rx_gain
  id: variable
  parameters:
    value: '40'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    comment: Sample rate
    value: 1e6
  states: {}
- name: sps
  id: variable
  parameters:
    comment: Samples per symbol; symbol rate is 250 ksym/s
    value: '4'
  states: {}
- name: const_view
  id: qtgui_const_sink_x
  parameters:
    autoscale: 'True'
    comment: A locked BPSK signal forms two clusters
    grid: 'True'
    name: Constellation (two BPSK clusters indicate lock)
    size: '1024'
    tr_tag: ''
    type: complex
    update_time: '0.1'
  states: {}
- name: costas
  id: digital_costas_loop_cc
  parameters:
    comment: Corrects carrier phase and frequency error; BPSK uses order 2
    order: '2'
    w: '0.0628'
  states: {}
- name: decoder
  id: digital_constellation_decoder_cb
  parameters:
    comment: Converts BPSK symbols to unpacked bits, one bit per byte
    constellation: bpsk
  states: {}
- name: diff_dec
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    comment: Reverses differential encoding and resolves the BPSK 180-degree ambiguity
    modulus: '2'
  states: {}
- name: preamble_correlator
  id: digital_correlate_access_code_tag_xx
  parameters:
    access_code: '''1111100110101000'''
    comment: Exact F9A8 detector; the tag marks the first Temporary Packet Length bit
    tagname: '''preamble_detected'''
    threshold: '0'
    type: byte
  states: {}
- name: matched
  id: root_raised_cosine_filter
  parameters:
    alpha: excess_bw
    comment: Receive matched filter using the same RRC response as the transmitter
    decim: '1'
    gain: '1.0'
    ntaps: 11*sps+1
    samp_rate: samp_rate
    sym_rate: samp_rate/sps
    type: fir_filter_ccf
  states: {}
- name: readme
  id: note
  parameters:
    note: |-
      VDE-TER Stage 2 Receiver (Node B) - Type 92/93 link layer over the existing BPSK PHY

      RRC Filter     : Applies the receive matched filter
      Symbol Sync    : Recovers symbol timing
      Costas Loop    : Recovers carrier frequency and phase
      Const Decoder  : Converts BPSK symbols to unpacked 0/1 bits
      Diff Decoder   : Reverses differential encoding and precedes the Correlator
      Correlator     : Detects F9A8 and adds the preamble_detected tag
      VDE RX Adapter : Runs Temporary Burst Extractor, Packet Parser, and Type decoder,
                       then prints the parsed result to the console

      Fixed 40-bit collection and Hello-specific decoding are not used.
      Temporary Packet Length defines the Packet size; each Message Length defines its boundary.
      The console prints one [VDE Message N] section for each Message in the Packet.
  states: {}
- name: rx_spectrum
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    average: '0.2'
    bw: samp_rate
    comment: Primary diagnostic view; increase TX gain first if no signal peak is visible
    fc: '0'
    fftsize: '2048'
    grid: 'True'
    name: Receive Spectrum (check signal presence here first)
    tr_tag: ''
    type: complex
    update_time: '0.1'
    ymax: '-20'
  states: {}
- name: sym_sync
  id: digital_symbol_sync_xx
  parameters:
    comment: Recovers symbol timing
    constellation: bpsk
    damping: '1.0'
    loop_bw: '0.045'
    max_dev: '1.5'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_MUELLER_AND_MULLER
    type: cc
  states: {}
- name: usrp_source
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    center_freq0: center_freq
    comment: AGC is disabled to prevent noise amplification when the signal is weak
    dev_addr: rx_dev
    gain0: rx_gain
    rx_agc0: Disabled
    samp_rate: samp_rate
    start_time: '-1'
    sync: sync
    type: fc32
  states: {}
- name: vde_rx_adapter
  id: epy_block
  parameters:
    _source_code: |
      # Thin GRC entry-point wrapper for the VDE RX Adapter.
      # VDERxSink in vdeter/radio/gnuradio_rx.py provides the implementation.
      # Message, Packet, and Burst logic is not duplicated here.
      import os
      import sys

      try:
          _base = os.path.dirname(os.path.abspath(__file__))
      except NameError:
          # __file__ is unavailable when GRC evaluates the code without a generated file.
          _base = os.path.abspath(os.getcwd())

      # Locate the src-layout vdeter package independently of the launch directory.
      _probe = _base
      while True:
          _src = os.path.join(_probe, 'src')
          if os.path.isfile(os.path.join(_src, 'vdeter', '__init__.py')):
              if _src not in sys.path:
                  sys.path.insert(0, _src)
              break
          _parent = os.path.dirname(_probe)
          if _parent == _probe:
              break
          _probe = _parent

      from vdeter.radio import gnuradio_rx


      class blk(gnuradio_rx.VDERxSink):
          """Recover VDE Packets after a preamble tag and print parsed Messages."""

          def __init__(self, tag_name='preamble_detected'):
              super().__init__(tag_name=tag_name)
    tag_name: '''preamble_detected'''
    comment: VDERxSink from vdeter/radio/gnuradio_rx.py
  states: {}

connections:
- [costas, '0', const_view, '0']
- [costas, '0', decoder, '0']
- [decoder, '0', diff_dec, '0']
- [diff_dec, '0', preamble_correlator, '0']
- [matched, '0', sym_sync, '0']
- [preamble_correlator, '0', vde_rx_adapter, '0']
- [sym_sync, '0', costas, '0']
- [usrp_source, '0', matched, '0']
- [usrp_source, '0', rx_spectrum, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
