options:
  parameters:
    author: voyager_3
    description: Hello BPSK 수신 (Node B)
    generate_options: qt_gui
    id: hello_rx
    output_language: python
    title: Hello BPSK 수신 (Node B)
  states: {}

blocks:
- name: bpsk
  id: variable_constellation
  parameters:
    comment: BPSK 성상도 — 송수신이 같은 것을 써야 한다
    const_points: '[-1, 1]'
    precision: '8'
    rot_sym: '2'
    sym_map: '[0, 1]'
    type: bpsk
  states: {}
- name: center_freq
  id: variable
  parameters:
    comment: 1e9 로 바꿔도 되지만 주파수 오차가 8배 커진다
    value: 157.2e6
  states: {}
- name: excess_bw
  id: variable
  parameters:
    comment: RRC 롤오프
    value: '0.35'
  states: {}
- name: out_file
  id: variable
  parameters:
    comment: 여기에 저장된다 -> find_pattern.py 로 확인
    value: os.path.expanduser('~/hello_rx.bin')
  states: {}
- name: rx_dev
  id: variable
  parameters:
    comment: 수신 장비
    value: '''type=b200'''
  states: {}
- name: rx_gain
  id: variable
  parameters:
    value: '40'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    comment: 샘플레이트
    value: 1e6
  states: {}
- name: sps
  id: variable
  parameters:
    comment: 심볼당 샘플 -> 심볼률 250 ksym/s
    value: '4'
  states: {}
- name: const_view
  id: qtgui_const_sink_x
  parameters:
    autoscale: 'True'
    comment: 잠기면 좌우 두 덩어리로 모인다
    grid: 'True'
    name: 성상도 (BPSK = 점 2개면 잠긴 것)
    size: '1024'
    tr_tag: ''
    type: complex
    update_time: '0.1'
  states: {}
- name: costas
  id: digital_costas_loop_cc
  parameters:
    comment: 반송파 위상/주파수 오차 보정 (BPSK 는 order 2)
    order: '2'
    w: '0.0628'
  states: {}
- name: decoder
  id: digital_constellation_decoder_cb
  parameters:
    comment: 심볼 -> 비트 (바이트당 1비트)
    constellation: bpsk
  states: {}
- name: diff_dec
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    comment: 송신의 차동 부호화를 되돌린다 (BPSK 180도 모호성 해소)
    modulus: '2'
  states: {}
- name: file_sink
  id: blocks_file_sink
  parameters:
    comment: find_pattern.py 로 확인할 파일
    file: out_file
    type: byte
    unbuffered: 'True'
  states: {}
- name: import_os
  id: import
  parameters:
    imports: import os
  states: {}
- name: matched
  id: root_raised_cosine_filter
  parameters:
    alpha: excess_bw
    comment: 정합필터 — 송신과 같은 RRC
    decim: '1'
    gain: '1.0'
    ntaps: 11*sps+1
    samp_rate: samp_rate
    sym_rate: samp_rate/sps
    type: fir_filter_ccf
  states: {}
- name: readme
  id: note
  parameters:
    note: |-
      BPSK Hello 수신 (Node B)   -   결과는 ~/hello_rx.bin 에 저장
      RRC Filter    : 송신과 같은 필터로 잡음 제거 Symbol Sync   : 심볼 한가운데 시점을 찾아 표본 추출 Costas Loop   : 두 장비의 주파수/위상 차이 보정 (BPSK 는 order 2) Const Decoder : 점 위치로 0/1 판정 Diff Decoder  : 송신의 차동부호화를 되돌림 Repack Bits   : 비트 8개를 1바이트로  (MSB first 필수)
      화면 보는 법 수신 스펙트럼 : 가운데 봉우리가 있어야 함. 없으면 tx_gain 부터 성상도        : 좌우 두 덩어리면 잠긴 것. 둥근 원이면 신호가 약함
      이 구성에는 동기어가 없어 바이트 경계가 매번 달라진다. 그래서 파일을 tools/find_pattern.py 로 확인한다 (8가지 정렬을 다 시도) 자세한 설명: docs/hello_bpsk_check.md
  states: {}
- name: repack
  id: blocks_repack_bits_bb
  parameters:
    comment: ★ MSB first 필수 — 기본값 LSB first 로 두면 바이트 안 비트가 뒤집힌다
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
    len_tag_key: ''
  states: {}
- name: rx_spectrum
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    average: '0.2'
    bw: samp_rate
    comment: ★ 디버깅 1순위 — 봉우리가 안 보이면 TX Gain 부터 올린다
    fc: '0'
    fftsize: '2048'
    grid: 'True'
    name: 수신 스펙트럼 (신호가 오는지 먼저 여기서 확인)
    tr_tag: ''
    type: complex
    update_time: '0.1'
    ymax: '-20'
  states: {}
- name: sym_sync
  id: digital_symbol_sync_xx
  parameters:
    comment: 심볼 시점 맞추기
    constellation: bpsk
    damping: '1.0'
    loop_bw: '0.045'
    max_dev: '1.5'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_MUELLER_AND_MULLER
    type: cc
  states: {}
- name: usrp_source
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    center_freq0: center_freq
    comment: AGC 끔 — 신호가 약할 때 잡음을 물고 올라가는 것을 막는다
    dev_addr: rx_dev
    gain0: rx_gain
    rx_agc0: Disabled
    samp_rate: samp_rate
    start_time: '-1'
    sync: sync
    type: fc32
  states: {}

connections:
- [costas, '0', const_view, '0']
- [costas, '0', decoder, '0']
- [decoder, '0', diff_dec, '0']
- [diff_dec, '0', repack, '0']
- [matched, '0', sym_sync, '0']
- [repack, '0', file_sink, '0']
- [sym_sync, '0', costas, '0']
- [usrp_source, '0', matched, '0']
- [usrp_source, '0', rx_spectrum, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
