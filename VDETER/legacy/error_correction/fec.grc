options:
  parameters:
    generate_options: qt_gui
    generator_class_name: PythonQtGuiGenerator
    generator_module: gnuradio.grc.workflows.python_qt_gui
    id: vde
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '2'
    min: '0'
    num_samps: '432'
    repeat: 'False'
    type: byte
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: '432'
    type: byte
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    LinkID: '12'
    _source_code: "#!/usr/bin/env python3\n# -*- coding: utf-8 -*-\n\"\"\"\nVDE-TER Turbo FEC Encoder for GNU Radio\n=======================================\n\nTarget profile\n--------------\n- VDE-TER Link ID 11\n- FEC input length: 432 bits\n- Turbo FEC rate: 1/2\n- Main punctured output: 864 bits\n- Termination/tail output: 10 bits\n- Total FEC output: 874 bits\n\nGNU Radio I/O\n-------------\nThis file defines an Embedded Python Block named ``blk`` when GNU Radio is\navailable.\n\nInput message port  : \"in\"\nOutput message port : \"out\"\n\nInput PDU data must be a PMT u8vector containing 432 *unpacked* bits:\n    [0, 1, 1, 0, ...]   # 432 items, each item is 0 or 1\n\nOutput PDU data is a PMT u8vector containing 874 coded bits:\n    [0, 1, 0, 1, ...]   # 874 items\n\nScope\n-----\nThis block performs ONLY the Turbo FEC encoding stage.\nCRC generation, byte-bit order conversion, scrambling, Link ID coding,\nsyncword insertion, modulation, and RRC filtering belong in separate blocks.\n\nReferences\n----------\n1) ITU-R Recommendation M.2092-2 (02/2026), VDES common PHY FEC/Turbo coding.\n2) Public implementation used as a cross-check:\n   collinlokken/grc-ais-vdes-framebuilder, vde-ter-framebuilder.py\n\nNotes for later extension\n-------------------------\nProfile parameters are kept in PROFILES so that additional Link IDs can be\nadded later without rewriting the encoder core.\n\"\"\"\n\nfrom __future__ import annotations\n\nfrom typing import Dict, List, Sequence, Tuple\n\n# GNU Radio is optional so that the encoder core can be unit-tested with\n# ordinary Python on a machine where GNU Radio is not installed.\ntry:\n    import pmt\n    from gnuradio import gr\n    _GNURADIO_AVAILABLE = True\nexcept ImportError:\n    pmt = None\n    gr = None\n    _GNURADIO_AVAILABLE = False\n\n\n# ---------------------------------------------------------------------------\n# [각주 1] Link ID별 Turbo FEC 파라미터\n# ---------------------------------------------------------------------------\n#\n# Link ID 11:\n#   K = 432        : Turbo encoder에 들어가는 정보 비트 수\n#   k1=2, k2=216  : K = k1 * k2, interleaver 계산 파라미터\n#   primes         : 규격의 permutation 계산에 사용하는 정수 집합\n#\n# puncture:\n#   두 RSC encoder의 한 clock 출력 순서를\n#   [X, Y0, Y1, X', Y0', Y1'] 로 놓았을 때,\n#   1 = 전송, 0 = 삭제(puncture)를 의미한다.\n#\n# Link ID 11의 main puncturing은 2-clock 주기로 반복되며\n# 각 input bit마다 평균 2 coded bit를 남겨 rate 1/2를 만든다.\n#\n# tail_puncture:\n#   RSC 상태를 0으로 종료(termination)시키는 6 clock\n#   (encoder 1: 3 clocks + encoder 2: 3 clocks)에 적용한다.\n#   Link ID 11에서는 총 10 tail bits가 남는다.\n#\nPROFILES: Dict[int, dict] = {\n    11: {\n        \"fec_input_bits\": 432,\n        \"k1\": 2,\n        \"k2\": 216,\n        \"primes\": [127, 191, 241, 5, 83, 109, 107, 179],\n        \"puncture\": [\n            [1, 1, 0, 0, 0, 0],\n            [1, 0, 0, 0, 1, 0],\n        ],\n        \"tail_puncture\": [\n            [1, 1, 0, 0, 0, 0],\n            [1, 1, 0, 0, 0, 0],\n            [1, 0, 0, 0, 0, 0],\n            [0, 0, 0, 1, 1, 0],\n            [0, 0, 0, 1, 1, 0],\n            [0, 0, 0, 1, 0, 0],\n        ],\n        \"expected_main_bits\": 864,\n        \"expected_tail_bits\": 10,\n        \"expected_total_bits\": 874,\n    },\n}\n\n\ndef _validate_bits(bits: Sequence[int], expected_len: int) -> List[int]:\n    \"\"\"\n    [각주 2] 입력 검증 함수.\n\n    Turbo encoder 입력은 packed byte(예: 0xA3)가 아니라,\n    0 또는 1 값을 하나씩 가진 'unpacked bit vector'이다.\n\n    예:\n        [1, 0, 1, 0]  -> 4 bits\n    \"\"\"\n    out = [int(b) for b in bits]\n\n    if len(out) != expected_len:\n        raise ValueError(\n            f\"Expected {expected_len} input bits, got {len(out)}.\"\n        )\n\n    if any(b not in (0, 1) for b in out):\n        raise ValueError(\"Every input item must be 0 or 1.\")\n\n    return out\n\n\ndef _build_permutation(profile: dict) -> List[int]:\n    \"\"\"\n    [각주 3] VDES Turbo interleaver permutation 생성.\n\n    s = 1 ... K에 대해 규격의 permutation 식으로 pi(s)를 계산한다.\n    반환값은 Python에서 바로 쓰기 위해 0-based index로 바꾼다.\n\n    interleaved[s-1] = input[pi(s)-1]\n    \"\"\"\n    k1 = int(profile[\"k1\"])\n    k2 = int(profile[\"k2\"])\n    primes = profile[\"primes\"]\n    K = k1 * k2\n\n    if k1 % 2 != 0:\n        raise ValueError(\"k1 must be even for the VDES permutation formula.\")\n\n    half_k1 = k1 // 2\n    permutation: List[int] = []\n\n    for s in range(1, K + 1):\n        m = (s - 1) % 2\n        i = (s - 1) // (2 * k2)\n        j = ((s - 1) // 2) - i * k2\n        t = (19 * i + 1) % half_k1\n        q = (t % 8) + 1\n        c = (primes[q - 1] * j + 21 * m) % k2\n        pi_s = 2 * (t + c * half_k1 + 1) - m\n\n        permutation.append(int(pi_s) - 1)\n\n    # permutation이 0..K-1을 정확히 한 번씩 포함하는지 확인.\n    if sorted(permutation) != list(range(K)):\n        raise RuntimeError(\"Generated interleaver permutation is not bijective.\")\n\n    return permutation\n\n\ndef _interleave(bits: Sequence[int], permutation: Sequence[int]) -> List[int]:\n    \"\"\"\n    [각주 4] 두 번째 RSC encoder에 넣을 입력 순서를 재배열한다.\n\n    Turbo Code는 같은 정보열을\n      - Encoder 1: 원래 순서\n      - Encoder 2: interleaved 순서\n    로 각각 인코딩한다.\n    \"\"\"\n    return [int(bits[index]) for index in permutation]\n\n\ndef _rsc_encode(\n    bits: Sequence[int],\n) -> Tuple[List[int], List[int], List[int], List[int], List[int], List[int]]:\n    \"\"\"\n    [각주 5] VDES용 8-state RSC(Recursive Systematic Convolutional) encoder.\n\n    각 input bit마다 3개 출력을 계산:\n        X  : systematic bit (= 입력 bit)\n        Y0 : parity output 0\n        Y1 : parity output 1\n\n    내부 메모리 D[0:3]는 모두 0에서 시작한다.\n\n    정보열을 모두 처리한 뒤에는 3 clock의 termination 동작을 수행하여\n    내부 상태를 000으로 되돌리기 위한 tail 출력도 생성한다.\n\n    반환:\n        X, Y0, Y1, X_tail, Y0_tail, Y1_tail\n    \"\"\"\n    D = [0, 0, 0]\n\n    X: List[int] = []\n    Y0: List[int] = []\n    Y1: List[int] = []\n\n    for raw_bit in bits:\n        bit = int(raw_bit) & 1\n\n        # Recursive feedback.\n        feedback = D[2] ^ D[1] ^ bit\n\n        # Systematic + parity outputs.\n        x = bit\n        y0 = feedback ^ D[0] ^ D[2]\n        y1 = feedback ^ D[0] ^ D[1] ^ D[2]\n\n        X.append(x)\n        Y0.append(y0)\n        Y1.append(y1)\n\n        # Shift register update:\n        # [D0, D1, D2] <- [feedback, old D0, old D1]\n        D = [feedback, D[0], D[1]]\n\n    # ------------------------------------------------------------------\n    # [각주 6] RSC termination / tail generation\n    # ------------------------------------------------------------------\n    # 정보열 처리가 끝난 뒤 3 clock 동안 encoder를 zero state로 복귀시킨다.\n    # tail systematic input은 현재 state에서 D1 XOR D2로 정해지고,\n    # feedback node에는 결과적으로 0이 들어가 state가 3번 shift되며 000이 된다.\n    #\n    X_tail: List[int] = []\n    Y0_tail: List[int] = []\n    Y1_tail: List[int] = []\n\n    for _ in range(3):\n        x_tail = D[1] ^ D[2]\n        feedback = 0\n\n        y0_tail = feedback ^ D[0] ^ D[2]\n        y1_tail = feedback ^ D[0] ^ D[1] ^ D[2]\n\n        X_tail.append(x_tail)\n        Y0_tail.append(y0_tail)\n        Y1_tail.append(y1_tail)\n\n        D = [feedback, D[0], D[1]]\n\n    if D != [0, 0, 0]:\n        raise RuntimeError(\"RSC termination failed to return state to zero.\")\n\n    return X, Y0, Y1, X_tail, Y0_tail, Y1_tail\n\n\ndef _apply_puncture(\n    streams: Sequence[Sequence[int]],\n    pattern: Sequence[Sequence[int]],\n) -> List[int]:\n    \"\"\"\n    [각주 7] Main data puncturing.\n\n    streams의 순서:\n        [X, Y0, Y1, X', Y0', Y1']\n\n    pattern 값의 의미:\n        0 -> 해당 bit 삭제\n        1 -> 해당 bit 1회 출력\n        2,3,... -> 해당 bit를 그 횟수만큼 반복 출력\n\n    현재 Link ID 11에서는 0/1만 사용하지만,\n    추후 다른 puncturing/repetition profile로 확장하기 쉽게 일반화했다.\n    \"\"\"\n    if len(streams) != 6:\n        raise ValueError(\"Exactly 6 RSC streams are required.\")\n\n    K = len(streams[0])\n    if any(len(stream) != K for stream in streams):\n        raise ValueError(\"All six RSC streams must have the same length.\")\n\n    output: List[int] = []\n\n    for n in range(K):\n        row = pattern[n % len(pattern)]\n\n        if len(row) != 6:\n            raise ValueError(\"Each puncturing row must have 6 entries.\")\n\n        for stream_index, repeat_count in enumerate(row):\n            repeat_count = int(repeat_count)\n            if repeat_count < 0:\n                raise ValueError(\"Puncturing entries cannot be negative.\")\n\n            output.extend(\n                [int(streams[stream_index][n])] * repeat_count\n            )\n\n    return output\n\n\ndef _apply_tail_puncture(\n    tail1: Tuple[Sequence[int], Sequence[int], Sequence[int]],\n    tail2: Tuple[Sequence[int], Sequence[int], Sequence[int]],\n    pattern: Sequence[Sequence[int]],\n) -> List[int]:\n    \"\"\"\n    [각주 8] 두 RSC encoder의 termination tail puncturing.\n\n    총 6 tail clocks:\n      clock 0~2 : Encoder 1의 X,Y0,Y1 tail\n      clock 3~5 : Encoder 2의 X',Y0',Y1' tail\n\n    Link ID 11에서는 puncturing 결과 총 10 bit가 출력된다.\n    \"\"\"\n    if len(pattern) != 6:\n        raise ValueError(\"Tail puncturing pattern must contain 6 rows.\")\n\n    if any(len(s) != 3 for s in tail1 + tail2):\n        raise ValueError(\"Each RSC encoder must generate exactly 3 tail clocks.\")\n\n    output: List[int] = []\n\n    # Encoder 1 termination clocks.\n    for clock in range(3):\n        row = pattern[clock]\n        sources = [\n            tail1[0][clock],\n            tail1[1][clock],\n            tail1[2][clock],\n            0, 0, 0,\n        ]\n\n        for value, repeat_count in zip(sources, row):\n            output.extend([int(value)] * int(repeat_count))\n\n    # Encoder 2 termination clocks.\n    for clock in range(3):\n        row = pattern[clock + 3]\n        sources = [\n            0, 0, 0,\n            tail2[0][clock],\n            tail2[1][clock],\n            tail2[2][clock],\n        ]\n\n        for value, repeat_count in zip(sources, row):\n            output.extend([int(value)] * int(repeat_count))\n\n    return output\n\n\ndef turbo_encode(bits: Sequence[int], link_id: int = 11) -> List[int]:\n    \"\"\"\n    [각주 9] 외부에서 호출하는 핵심 함수.\n\n    처리 순서:\n        432-bit FEC input\n            -> RSC Encoder #1\n            -> Interleaver\n            -> RSC Encoder #2\n            -> rate-1/2 puncturing\n            -> RSC termination/tail puncturing\n            -> 874 coded bits\n\n    주의:\n    - CRC를 계산하지 않는다.\n    - byte 단위 bit-order reversal을 하지 않는다.\n    - scrambling을 하지 않는다.\n    - π/4-QPSK 변조를 하지 않는다.\n    \"\"\"\n    if link_id not in PROFILES:\n        raise ValueError(\n            f\"Unsupported Link ID {link_id}. \"\n            f\"Currently implemented: {sorted(PROFILES)}\"\n        )\n\n    profile = PROFILES[link_id]\n    K = int(profile[\"fec_input_bits\"])\n\n    input_bits = _validate_bits(bits, K)\n    permutation = _build_permutation(profile)\n\n    # RSC Encoder #1: 원래 bit 순서.\n    x, y0, y1, xt, y0t, y1t = _rsc_encode(input_bits)\n\n    # RSC Encoder #2: interleaved bit 순서.\n    interleaved = _interleave(input_bits, permutation)\n    xp, y0p, y1p, xpt, y0pt, y1pt = _rsc_encode(interleaved)\n\n    main_bits = _apply_puncture(\n        [x, y0, y1, xp, y0p, y1p],\n        profile[\"puncture\"],\n    )\n\n    tail_bits = _apply_tail_puncture(\n        (xt, y0t, y1t),\n        (xpt, y0pt, y1pt),\n        profile[\"tail_puncture\"],\n    )\n\n    encoded = main_bits + tail_bits\n\n    # 길이는 구현 오류를 가장 빨리 잡을 수 있는 sanity check.\n    if len(main_bits) != profile[\"expected_main_bits\"]:\n        raise RuntimeError(\n            f\"Unexpected main FEC length: {len(main_bits)} \"\n            f\"(expected {profile['expected_main_bits']}).\"\n        )\n\n    if len(tail_bits) != profile[\"expected_tail_bits\"]:\n        raise RuntimeError(\n            f\"Unexpected FEC tail length: {len(tail_bits)} \"\n            f\"(expected {profile['expected_tail_bits']}).\"\n        )\n\n    if len(encoded) != profile[\"expected_total_bits\"]:\n        raise RuntimeError(\n            f\"Unexpected total FEC length: {len(encoded)} \"\n            f\"(expected {profile['expected_total_bits']}).\"\n        )\n\n    return encoded\n\n\n# ===========================================================================\n# GNU Radio Embedded Python Block\n# ===========================================================================\n#\n# GRC에서 Embedded Python Block을 만들고 이 파일 내용을 넣으면,\n# message port \"in\"으로 432-bit u8vector PDU를 받고\n# message port \"out\"으로 874-bit u8vector PDU를 내보낸다.\n#\nif _GNURADIO_AVAILABLE:\n\n    class blk(gr.basic_block):\n        \"\"\"\n        VDE-TER Turbo FEC Encoder (PDU)\n        Default: Link ID 11\n        \"\"\"\n\n        def __init__(self, LinkID=11, verbose=False):\n            # [각주 10] LinkID를 parameter로 둔 이유:\n            # 현재는 11만 구현했지만 이후 PROFILES에 다른 Link ID를 추가하면\n            # 같은 block interface를 유지할 수 있다.\n            gr.basic_block.__init__(\n                self,\n                name=\"VDE-TER Turbo FEC Encoder\",\n                in_sig=None,\n                out_sig=None,\n            )\n\n            self.LinkID = int(LinkID)\n            self.verbose = bool(verbose)\n\n            if self.LinkID not in PROFILES:\n                raise ValueError(\n                    f\"Unsupported Link ID {self.LinkID}. \"\n                    f\"Implemented profiles: {sorted(PROFILES)}\"\n                )\n\n            # PDU message ports.\n            self.message_port_register_in(pmt.intern(\"in\"))\n            self.message_port_register_out(pmt.intern(\"out\"))\n            self.set_msg_handler(pmt.intern(\"in\"), self._handle_pdu)\n\n        def _handle_pdu(self, msg):\n            \"\"\"\n            [각주 11] GNU Radio PDU 처리 함수.\n\n            PDU 형식:\n                (metadata, u8vector)\n\n            metadata는 그대로 보존해서 output PDU로 전달한다.\n            \"\"\"\n            try:\n                if not pmt.is_pair(msg):\n                    raise ValueError(\n                        \"Input must be a PDU pair: (metadata, u8vector).\"\n                    )\n\n                meta = pmt.car(msg)\n                data = pmt.cdr(msg)\n\n                if not pmt.is_u8vector(data):\n                    raise ValueError(\n                        \"PDU payload must be a PMT u8vector of unpacked bits.\"\n                    )\n\n                bits = list(pmt.u8vector_elements(data))\n                encoded = turbo_encode(bits, self.LinkID)\n\n                out_vec = pmt.init_u8vector(len(encoded), encoded)\n                out_pdu = pmt.cons(meta, out_vec)\n\n                self.message_port_pub(pmt.intern(\"out\"), out_pdu)\n\n                if self.verbose:\n                    print(\n                        f\"[VDE-TER Turbo FEC] Link ID {self.LinkID}: \"\n                        f\"{len(bits)} -> {len(encoded)} bits\"\n                    )\n\n            except Exception as exc:\n                # Embedded Python Block 디버깅 시 터미널에서 원인을 바로 볼 수 있게 한다.\n                print(f\"[VDE-TER Turbo FEC ERROR] {exc}\")\n\n\ndef _self_test() -> None:\n    \"\"\"\n    GNU Radio 없이도 실행 가능한 최소 self-test.\n\n    확인 항목:\n    1) 432 bits 입력 허용\n    2) 결과가 정확히 874 bits인지\n    3) 출력이 모두 0/1인지\n    4) all-zero 입력에서 RSC/tail 처리가 안정적인지\n    5) deterministic pseudo-pattern 입력에서도 길이가 유지되는지\n    \"\"\"\n    zeros = [0] * 432\n    z = turbo_encode(zeros, 11)\n\n    assert len(z) == 874\n    assert set(z).issubset({0, 1})\n    assert z == [0] * 874\n\n    # 단순하지만 재현 가능한 비트 패턴.\n    test_bits = [((i * 7 + 3) ^ (i >> 2)) & 1 for i in range(432)]\n    coded = turbo_encode(test_bits, 11)\n\n    assert len(coded) == 874\n    assert set(coded).issubset({0, 1})\n\n    print(\"[PASS] Link ID 11 Turbo encoder self-test\")\n    print(\"       input  : 432 bits\")\n    print(\"       output : 874 bits (864 main + 10 tail)\")\n\n\nif __name__ == \"__main__\":\n    _self_test()\n\n"
    verbose: 'True'
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    LinkID: '12'
    _source_code: "#!/usr/bin/env python3\n# -*- coding: utf-8 -*-\n\"\"\"\nVDE-TER Turbo FEC Decoder for GNU Radio\n=======================================\n\nTarget profile\n--------------\n- VDE-TER Link ID 11\n- FEC coded input length : 874 bits\n    - main punctured bits : 864\n    - termination/tail    : 10\n- Decoded output length   : 432 bits\n- Turbo iterations        : configurable (default 6)\n\nGNU Radio I/O\n-------------\nThis file defines an Embedded Python Block named ``blk`` when GNU Radio is\navailable.\n\nMessage input port  : \"in\"\nMessage output port : \"out\"\n\nAccepted input PDU payloads:\n\n1) PMT u8vector, length 874\n   Hard bits:\n       [0, 1, 1, 0, ...]\n   Each received bit is converted to an internal LLR.\n\n2) PMT f32vector, length 874\n   Soft LLR values from a demodulator:\n       positive LLR -> bit 0 is more likely\n       negative LLR -> bit 1 is more likely\n\nOutput:\n    PMT u8vector, length 432\n    decoded unpacked bits (0/1)\n\nImportant\n---------\nThis decoder must receive the FEC codeword AFTER descrambling.\nIt does NOT perform:\n- RF demodulation\n- pi/4-QPSK demapping\n- descrambling\n- CRC checking\n- byte bit-order restoration\n\nThose stages should be separate GNU Radio blocks.\n\nDecoder algorithm\n-----------------\nThe VDE-TER standard defines the Turbo encoder/code structure. A receiver is\nfree to choose a suitable decoding implementation. This implementation uses:\n\n    iterative Turbo decoding\n        + two constituent 8-state RSC decoders\n        + Max-Log-MAP SISO decoding\n        + interleaved/deinterleaved extrinsic LLR exchange\n\nMax-Log-MAP is a practical approximation of Log-MAP and is considerably\nsimpler to implement in a GNU Radio Embedded Python Block.\n\nReferences\n----------\n1) ITU-R Recommendation M.2092-2 (02/2026), VDES FEC/Turbo coding.\n2) Encoder cross-check:\n   collinlokken/grc-ais-vdes-framebuilder,\n   vde-ter-framebuilder.py\n\nThis file is designed to correspond to:\n    vde_ter_turbo_encoder_link11.py\n\"\"\"\n\nfrom __future__ import annotations\n\nfrom typing import Dict, List, Sequence, Tuple\nimport numpy as np\n\n# GNU Radio is optional so the decoder core can be tested with plain Python.\ntry:\n    import pmt\n    from gnuradio import gr\n    _GNURADIO_AVAILABLE = True\nexcept ImportError:\n    pmt = None\n    gr = None\n    _GNURADIO_AVAILABLE = False\n\n\n# =============================================================================\n# [각주 1] Link ID별 FEC 프로파일\n# =============================================================================\n#\n# 현재는 Link ID 11만 구현.\n# 이후 Link ID 12~19를 추가할 때 이 딕셔너리에 각 profile의\n# K, interleaver, puncturing 정보를 추가하면 decoder core를 재사용할 수 있다.\n#\nPROFILES: Dict[int, dict] = {\n    11: {\n        \"fec_input_bits\": 432,\n        \"coded_bits\": 874,\n\n        # VDES Turbo interleaver parameters\n        \"k1\": 2,\n        \"k2\": 216,\n        \"primes\": [127, 191, 241, 5, 83, 109, 107, 179],\n\n        # 한 clock에서 두 RSC가 만드는 6개 출력을\n        # [X, Y0, Y1, X', Y0', Y1'] 순서로 놓았을 때\n        # 1=전송, 0=puncture(미전송)\n        \"puncture\": [\n            [1, 1, 0, 0, 0, 0],\n            [1, 0, 0, 0, 1, 0],\n        ],\n\n        # RSC termination 6 clocks에 대한 puncturing pattern.\n        # Encoder 1 tail 3 clocks + Encoder 2 tail 3 clocks.\n        \"tail_puncture\": [\n            [1, 1, 0, 0, 0, 0],\n            [1, 1, 0, 0, 0, 0],\n            [1, 0, 0, 0, 0, 0],\n            [0, 0, 0, 1, 1, 0],\n            [0, 0, 0, 1, 1, 0],\n            [0, 0, 0, 1, 0, 0],\n        ],\n    },\n}\n\n\n# =============================================================================\n# [각주 2] Interleaver / Deinterleaver\n# =============================================================================\n\ndef _build_permutation(profile: dict) -> np.ndarray:\n    \"\"\"\n    VDES Turbo interleaver permutation pi(s)를 생성한다.\n\n    반환:\n        permutation[out_index] = original_index\n\n    즉:\n        interleaved = original[permutation]\n    \"\"\"\n    k1 = int(profile[\"k1\"])\n    k2 = int(profile[\"k2\"])\n    primes = profile[\"primes\"]\n    K = k1 * k2\n\n    half_k1 = k1 // 2\n    if half_k1 <= 0:\n        raise ValueError(\"Invalid k1.\")\n\n    permutation: List[int] = []\n\n    for s in range(1, K + 1):\n        m = (s - 1) % 2\n        i = (s - 1) // (2 * k2)\n        j = ((s - 1) // 2) - i * k2\n        t = (19 * i + 1) % half_k1\n        q = (t % 8) + 1\n        c = (primes[q - 1] * j + 21 * m) % k2\n        pi_s = 2 * (t + c * half_k1 + 1) - m\n        permutation.append(int(pi_s) - 1)\n\n    permutation = np.asarray(permutation, dtype=np.int32)\n\n    if not np.array_equal(np.sort(permutation), np.arange(K)):\n        raise RuntimeError(\"Interleaver permutation is not bijective.\")\n\n    return permutation\n\n\ndef _inverse_permutation(permutation: np.ndarray) -> np.ndarray:\n    \"\"\"\n    deinterleaver index 생성.\n\n    interleaved = original[permutation]\n    original    = interleaved[inverse]\n    \"\"\"\n    inverse = np.empty_like(permutation)\n    inverse[permutation] = np.arange(len(permutation), dtype=np.int32)\n    return inverse\n\n\n# =============================================================================\n# [각주 3] 8-state RSC trellis\n# =============================================================================\n#\n# Encoder와 동일한 상태식:\n#\n#   feedback = D2 XOR D1 XOR u\n#   X        = u\n#   Y0       = feedback XOR D0 XOR D2\n#   Y1       = feedback XOR D0 XOR D1 XOR D2\n#\n#   next state = [feedback, D0, D1]\n#\n# 3개의 memory bit -> 2^3 = 8 states.\n#\n\ndef _state_to_bits(state: int) -> Tuple[int, int, int]:\n    \"\"\"state 번호(0~7)를 [D0,D1,D2]로 변환.\"\"\"\n    return (\n        (state >> 2) & 1,\n        (state >> 1) & 1,\n        state & 1,\n    )\n\n\ndef _bits_to_state(D0: int, D1: int, D2: int) -> int:\n    \"\"\"[D0,D1,D2]를 state 번호(0~7)로 변환.\"\"\"\n    return (int(D0) << 2) | (int(D1) << 1) | int(D2)\n\n\ndef _build_trellis():\n    \"\"\"\n    데이터 clock용 trellis와 termination clock용 trellis 생성.\n\n    데이터 clock:\n        각 state에서 u=0 또는 u=1, 총 2개 branch.\n\n    termination clock:\n        encoder state를 000으로 되돌리기 위해 입력 tail bit가\n        state에 의해 결정되므로 state당 branch가 1개뿐이다.\n    \"\"\"\n    next_state = np.zeros((8, 2), dtype=np.int32)\n    y0 = np.zeros((8, 2), dtype=np.int8)\n    y1 = np.zeros((8, 2), dtype=np.int8)\n\n    tail_next = np.zeros(8, dtype=np.int32)\n    tail_u = np.zeros(8, dtype=np.int8)\n    tail_y0 = np.zeros(8, dtype=np.int8)\n    tail_y1 = np.zeros(8, dtype=np.int8)\n\n    for state in range(8):\n        D0, D1, D2 = _state_to_bits(state)\n\n        # 일반 information-bit transition\n        for u in (0, 1):\n            feedback = D2 ^ D1 ^ u\n\n            next_state[state, u] = _bits_to_state(\n                feedback, D0, D1\n            )\n\n            y0[state, u] = feedback ^ D0 ^ D2\n            y1[state, u] = feedback ^ D0 ^ D1 ^ D2\n\n        # termination transition:\n        # u_tail = D1 XOR D2를 넣으면 feedback=0이 된다.\n        u_tail = D1 ^ D2\n\n        tail_u[state] = u_tail\n        tail_next[state] = _bits_to_state(0, D0, D1)\n        tail_y0[state] = D0 ^ D2\n        tail_y1[state] = D0 ^ D1 ^ D2\n\n    # 모든 state가 3 termination clocks 후 000으로 가는지 확인.\n    for initial_state in range(8):\n        state = initial_state\n        for _ in range(3):\n            state = int(tail_next[state])\n        if state != 0:\n            raise RuntimeError(\"Invalid RSC termination trellis.\")\n\n    return next_state, y0, y1, tail_next, tail_u, tail_y0, tail_y1\n\n\n(\n    _NEXT_STATE,\n    _Y0,\n    _Y1,\n    _TAIL_NEXT,\n    _TAIL_U,\n    _TAIL_Y0,\n    _TAIL_Y1,\n) = _build_trellis()\n\n\n# =============================================================================\n# [각주 4] Depuncturing\n# =============================================================================\n\ndef _to_llr(\n    received: Sequence[float],\n    *,\n    hard_input: bool,\n    hard_llr: float,\n    expected_len: int,\n) -> np.ndarray:\n    \"\"\"\n    입력을 LLR(Log-Likelihood Ratio)로 변환.\n\n    이 코드의 LLR convention:\n        LLR > 0  -> bit 0 쪽이 더 유력\n        LLR < 0  -> bit 1 쪽이 더 유력\n\n    hard_input=True:\n        입력 0 -> +hard_llr\n        입력 1 -> -hard_llr\n\n    hard_input=False:\n        입력 자체를 LLR로 간주.\n    \"\"\"\n    values = np.asarray(received, dtype=np.float64)\n\n    if len(values) != expected_len:\n        raise ValueError(\n            f\"Expected {expected_len} coded values, got {len(values)}.\"\n        )\n\n    if hard_input:\n        if np.any((values != 0) & (values != 1)):\n            raise ValueError(\"Hard input must contain only 0 or 1.\")\n        return np.where(values == 0, float(hard_llr), -float(hard_llr))\n\n    if not np.all(np.isfinite(values)):\n        raise ValueError(\"Soft LLR input contains NaN or infinity.\")\n\n    return values\n\n\ndef _depuncture(\n    received_llr: np.ndarray,\n    profile: dict,\n) -> Tuple[np.ndarray, np.ndarray, np.ndarray]:\n    \"\"\"\n    punctured 874-value codeword를 RSC별 observation으로 복원한다.\n\n    반환:\n        streams : shape (6, K)\n            [X, Y0, Y1, X', Y0', Y1']\n\n        tail1 : shape (3,3)\n            Encoder 1 termination observations\n            [X_tail, Y0_tail, Y1_tail]\n\n        tail2 : shape (3,3)\n            Encoder 2 termination observations\n\n    puncture된 bit는 수신 관측이 없으므로 LLR=0으로 둔다.\n    LLR=0은 decoder 입장에서 \"0/1 어느 쪽인지 정보 없음\"을 뜻한다.\n    \"\"\"\n    K = int(profile[\"fec_input_bits\"])\n\n    streams = np.zeros((6, K), dtype=np.float64)\n    tail1 = np.zeros((3, 3), dtype=np.float64)\n    tail2 = np.zeros((3, 3), dtype=np.float64)\n\n    cursor = 0\n\n    # Main 432 clocks\n    pattern = profile[\"puncture\"]\n\n    for n in range(K):\n        row = pattern[n % len(pattern)]\n\n        for stream_index, count in enumerate(row):\n            for _ in range(int(count)):\n                streams[stream_index, n] += received_llr[cursor]\n                cursor += 1\n\n    # Encoder 1 termination: first 3 tail pattern rows.\n    tail_pattern = profile[\"tail_puncture\"]\n\n    for clock in range(3):\n        row = tail_pattern[clock]\n\n        for stream_index in range(3):\n            for _ in range(int(row[stream_index])):\n                tail1[stream_index, clock] += received_llr[cursor]\n                cursor += 1\n\n    # Encoder 2 termination: last 3 tail pattern rows.\n    for clock in range(3):\n        row = tail_pattern[clock + 3]\n\n        for stream_index in range(3, 6):\n            for _ in range(int(row[stream_index])):\n                tail2[stream_index - 3, clock] += received_llr[cursor]\n                cursor += 1\n\n    if cursor != len(received_llr):\n        raise RuntimeError(\n            f\"Depuncturing consumed {cursor} values, \"\n            f\"but input contains {len(received_llr)}.\"\n        )\n\n    return streams, tail1, tail2\n\n\n# =============================================================================\n# [각주 5] Max-Log-MAP constituent decoder\n# =============================================================================\n\ndef _siso_max_log_map(\n    systematic_llr: np.ndarray,\n    parity_y0_llr: np.ndarray,\n    parity_y1_llr: np.ndarray,\n    tail_llr: np.ndarray,\n    apriori_llr: np.ndarray,\n) -> np.ndarray:\n    \"\"\"\n    하나의 RSC constituent code에 대한 SISO decoder.\n\n    SISO:\n        Soft Input Soft Output\n\n    입력:\n        systematic_llr : 정보 bit의 channel LLR\n        parity_y0_llr  : Y0 parity channel LLR\n        parity_y1_llr  : Y1 parity channel LLR\n        tail_llr       : termination 3 clocks 관측\n        apriori_llr    : 다른 Turbo decoder가 전달한 extrinsic 정보\n\n    출력:\n        posterior LLR, 길이 K\n\n    Max-Log-MAP:\n        trellis의 forward metric(alpha)와 backward metric(beta)를 구하고,\n        bit=0 경로와 bit=1 경로의 최대 metric 차이로 posterior LLR을 계산.\n\n    LLR > 0 -> decoded bit 0\n    LLR < 0 -> decoded bit 1\n    \"\"\"\n    K = len(systematic_llr)\n    T = K + 3                  # 3 termination clocks 포함\n    NEG_INF = -1.0e30\n\n    # ---------------------------------------------------------------------\n    # Branch metric gamma\n    # ---------------------------------------------------------------------\n    #\n    # received LLR L과 후보 bit b에 대해\n    #      0.5 * (1 - 2b) * L\n    # 을 더한다.\n    #\n    gamma = np.empty((K, 8, 2), dtype=np.float64)\n\n    for t in range(K):\n        sys_plus_apriori = systematic_llr[t] + apriori_llr[t]\n\n        for state in range(8):\n            for u in (0, 1):\n                gamma[t, state, u] = 0.5 * (\n                    (1 - 2 * u) * sys_plus_apriori\n                    + (1 - 2 * int(_Y0[state, u])) * parity_y0_llr[t]\n                    + (1 - 2 * int(_Y1[state, u])) * parity_y1_llr[t]\n                )\n\n    # ---------------------------------------------------------------------\n    # Forward recursion alpha\n    # ---------------------------------------------------------------------\n    alpha = np.full((T + 1, 8), NEG_INF, dtype=np.float64)\n\n    # RSC encoder는 state 000에서 시작.\n    alpha[0, 0] = 0.0\n\n    for t in range(K):\n        next_metric = np.full(8, NEG_INF, dtype=np.float64)\n\n        for state in range(8):\n            base = alpha[t, state]\n\n            for u in (0, 1):\n                ns = int(_NEXT_STATE[state, u])\n                metric = base + gamma[t, state, u]\n\n                if metric > next_metric[ns]:\n                    next_metric[ns] = metric\n\n        # 수치가 불필요하게 커지는 것을 막기 위한 normalization.\n        next_metric -= np.max(next_metric)\n        alpha[t + 1] = next_metric\n\n    # 3 termination clocks\n    for tail_clock in range(3):\n        t = K + tail_clock\n        next_metric = np.full(8, NEG_INF, dtype=np.float64)\n\n        for state in range(8):\n            u = int(_TAIL_U[state])\n            ns = int(_TAIL_NEXT[state])\n\n            branch = 0.5 * (\n                (1 - 2 * u) * tail_llr[0, tail_clock]\n                + (1 - 2 * int(_TAIL_Y0[state])) * tail_llr[1, tail_clock]\n                + (1 - 2 * int(_TAIL_Y1[state])) * tail_llr[2, tail_clock]\n            )\n\n            metric = alpha[t, state] + branch\n\n            if metric > next_metric[ns]:\n                next_metric[ns] = metric\n\n        next_metric -= np.max(next_metric)\n        alpha[t + 1] = next_metric\n\n    # ---------------------------------------------------------------------\n    # Backward recursion beta\n    # ---------------------------------------------------------------------\n    beta = np.full((T + 1, 8), NEG_INF, dtype=np.float64)\n\n    # termination 이후 최종 state는 000으로 제한.\n    beta[T, 0] = 0.0\n\n    # termination 구간 backward\n    for tail_clock in range(2, -1, -1):\n        t = K + tail_clock\n        current = np.full(8, NEG_INF, dtype=np.float64)\n\n        for state in range(8):\n            u = int(_TAIL_U[state])\n            ns = int(_TAIL_NEXT[state])\n\n            branch = 0.5 * (\n                (1 - 2 * u) * tail_llr[0, tail_clock]\n                + (1 - 2 * int(_TAIL_Y0[state])) * tail_llr[1, tail_clock]\n                + (1 - 2 * int(_TAIL_Y1[state])) * tail_llr[2, tail_clock]\n            )\n\n            current[state] = branch + beta[t + 1, ns]\n\n        current -= np.max(current)\n        beta[t] = current\n\n    # information 구간 backward\n    for t in range(K - 1, -1, -1):\n        current = np.full(8, NEG_INF, dtype=np.float64)\n\n        for state in range(8):\n            best = NEG_INF\n\n            for u in (0, 1):\n                ns = int(_NEXT_STATE[state, u])\n                metric = gamma[t, state, u] + beta[t + 1, ns]\n\n                if metric > best:\n                    best = metric\n\n            current[state] = best\n\n        current -= np.max(current)\n        beta[t] = current\n\n    # ---------------------------------------------------------------------\n    # Posterior LLR\n    # ---------------------------------------------------------------------\n    posterior = np.empty(K, dtype=np.float64)\n\n    for t in range(K):\n        best_bit0 = NEG_INF\n        best_bit1 = NEG_INF\n\n        for state in range(8):\n            for u in (0, 1):\n                ns = int(_NEXT_STATE[state, u])\n\n                metric = (\n                    alpha[t, state]\n                    + gamma[t, state, u]\n                    + beta[t + 1, ns]\n                )\n\n                if u == 0:\n                    if metric > best_bit0:\n                        best_bit0 = metric\n                else:\n                    if metric > best_bit1:\n                        best_bit1 = metric\n\n        posterior[t] = best_bit0 - best_bit1\n\n    return posterior\n\n\n# =============================================================================\n# [각주 6] Iterative Turbo Decoder\n# =============================================================================\n\ndef turbo_decode(\n    received: Sequence[float],\n    link_id: int = 11,\n    iterations: int = 6,\n    *,\n    hard_input: bool = True,\n    hard_llr: float = 2.0,\n) -> Tuple[List[int], np.ndarray]:\n    \"\"\"\n    외부에서 직접 호출할 수 있는 Turbo decoder 핵심 함수.\n\n    Parameters\n    ----------\n    received:\n        hard_input=True\n            874개의 0/1 coded bits\n\n        hard_input=False\n            874개의 soft LLR values\n\n    link_id:\n        현재 11 지원.\n        추후 PROFILES 확장을 위해 parameter로 유지.\n\n    iterations:\n        Turbo decoder 반복 횟수.\n        기본값 6.\n        증가시키면 성능이 좋아질 수 있지만 처리시간도 증가한다.\n\n    hard_llr:\n        hard bit를 내부 LLR로 바꿀 때 사용하는 신뢰도 크기.\n        단순 bit-flip 실험용 기본값 2.0.\n        실제 무선 링크에서는 hard input보다 demodulator의 soft LLR 사용을 권장.\n\n    Returns\n    -------\n    decoded_bits:\n        길이 432의 0/1 list\n\n    posterior_llr:\n        최종 decoded bit의 posterior LLR.\n        디버깅/성능분석 시 사용할 수 있다.\n    \"\"\"\n    if link_id not in PROFILES:\n        raise ValueError(\n            f\"Unsupported Link ID {link_id}. \"\n            f\"Implemented profiles: {sorted(PROFILES)}\"\n        )\n\n    if iterations < 1:\n        raise ValueError(\"iterations must be >= 1.\")\n\n    if hard_llr <= 0:\n        raise ValueError(\"hard_llr must be > 0.\")\n\n    profile = PROFILES[link_id]\n    K = int(profile[\"fec_input_bits\"])\n\n    received_llr = _to_llr(\n        received,\n        hard_input=hard_input,\n        hard_llr=hard_llr,\n        expected_len=int(profile[\"coded_bits\"]),\n    )\n\n    # punctured stream을 각 constituent encoder 관측으로 복원.\n    streams, tail1, tail2 = _depuncture(received_llr, profile)\n\n    # streams:\n    #   0 = X  (systematic)\n    #   1 = Y0\n    #   2 = Y1\n    #   3 = X'  (Link ID 11 main puncturing에서는 전송되지 않음)\n    #   4 = Y0'\n    #   5 = Y1'\n    #\n    systematic_1 = streams[0]\n\n    permutation = _build_permutation(profile)\n    inverse = _inverse_permutation(permutation)\n\n    # 두 번째 RSC의 information bit는 interleaved(original)이므로\n    # systematic channel observation도 동일한 순서로 interleave한다.\n    systematic_2 = systematic_1[permutation]\n\n    # Decoder 1이 Decoder 2에게 받은 a-priori 정보.\n    apriori_1 = np.zeros(K, dtype=np.float64)\n\n    posterior_2 = None\n\n    # ---------------------------------------------------------------------\n    # Turbo iterations\n    # ---------------------------------------------------------------------\n    for _ in range(int(iterations)):\n\n        # Constituent Decoder #1\n        posterior_1 = _siso_max_log_map(\n            systematic_1,\n            streams[1],\n            streams[2],\n            tail1,\n            apriori_1,\n        )\n\n        # Extrinsic = posterior - systematic(channel) - prior\n        extrinsic_1 = posterior_1 - systematic_1 - apriori_1\n\n        # 과도한 값이 반복 과정에서 폭증하지 않도록 제한.\n        extrinsic_1 = np.clip(extrinsic_1, -50.0, 50.0)\n\n        # Decoder #2 순서로 interleave.\n        apriori_2 = extrinsic_1[permutation]\n\n        # Constituent Decoder #2\n        posterior_2 = _siso_max_log_map(\n            systematic_2,\n            streams[4],\n            streams[5],\n            tail2,\n            apriori_2,\n        )\n\n        extrinsic_2 = posterior_2 - systematic_2 - apriori_2\n        extrinsic_2 = np.clip(extrinsic_2, -50.0, 50.0)\n\n        # 다시 original bit 순서로 deinterleave하여 Decoder #1에 전달.\n        apriori_1 = extrinsic_2[inverse]\n\n    # Decoder #2 posterior는 interleaved order.\n    # 원래 432-bit 순서로 되돌린다.\n    final_llr = posterior_2[inverse]\n\n    # 이 코드의 LLR convention:\n    #   >= 0 -> 0\n    #   <  0 -> 1\n    decoded = (final_llr < 0.0).astype(np.uint8)\n\n    return decoded.tolist(), final_llr\n\n\n# =============================================================================\n# GNU Radio Embedded Python Block\n# =============================================================================\n\nif _GNURADIO_AVAILABLE:\n\n    class blk(gr.basic_block):\n        \"\"\"\n        VDE-TER Turbo FEC Decoder (PDU)\n\n        Parameters exposed in GRC:\n            LinkID      : default 11\n            iterations  : default 6\n            hard_llr    : default 2.0\n            verbose     : print decode information\n        \"\"\"\n\n        def __init__(\n            self,\n            LinkID=11,\n            iterations=6,\n            hard_llr=2.0,\n            verbose=False,\n        ):\n            gr.basic_block.__init__(\n                self,\n                name=\"VDE-TER Turbo FEC Decoder\",\n                in_sig=None,\n                out_sig=None,\n            )\n\n            self.LinkID = int(LinkID)\n            self.iterations = int(iterations)\n            self.hard_llr = float(hard_llr)\n            self.verbose = bool(verbose)\n\n            if self.LinkID not in PROFILES:\n                raise ValueError(\n                    f\"Unsupported Link ID {self.LinkID}. \"\n                    f\"Implemented profiles: {sorted(PROFILES)}\"\n                )\n\n            # Message/PDU ports\n            self.message_port_register_in(pmt.intern(\"in\"))\n            self.message_port_register_out(pmt.intern(\"out\"))\n\n            self.set_msg_handler(\n                pmt.intern(\"in\"),\n                self._handle_pdu,\n            )\n\n        def _handle_pdu(self, msg):\n            \"\"\"\n            GNU Radio PDU handler.\n\n            u8vector:\n                hard decision 0/1 input\n\n            f32vector:\n                soft LLR input\n\n            metadata는 그대로 output PDU에 전달한다.\n            \"\"\"\n            try:\n                if not pmt.is_pair(msg):\n                    raise ValueError(\n                        \"Input must be a PDU pair: (metadata, vector).\"\n                    )\n\n                meta = pmt.car(msg)\n                payload = pmt.cdr(msg)\n\n                # ---------------------------------------------------------\n                # Hard-bit PDU\n                # ---------------------------------------------------------\n                if pmt.is_u8vector(payload):\n                    received = list(pmt.u8vector_elements(payload))\n\n                    decoded, final_llr = turbo_decode(\n                        received,\n                        link_id=self.LinkID,\n                        iterations=self.iterations,\n                        hard_input=True,\n                        hard_llr=self.hard_llr,\n                    )\n\n                    mode = \"hard\"\n\n                # ---------------------------------------------------------\n                # Soft-LLR PDU\n                # ---------------------------------------------------------\n                elif hasattr(pmt, \"is_f32vector\") and pmt.is_f32vector(payload):\n                    received = list(pmt.f32vector_elements(payload))\n\n                    decoded, final_llr = turbo_decode(\n                        received,\n                        link_id=self.LinkID,\n                        iterations=self.iterations,\n                        hard_input=False,\n                    )\n\n                    mode = \"soft-LLR\"\n\n                else:\n                    raise ValueError(\n                        \"PDU payload must be either \"\n                        \"u8vector(874 hard bits) or \"\n                        \"f32vector(874 LLR values).\"\n                    )\n\n                out_vec = pmt.init_u8vector(len(decoded), decoded)\n                out_pdu = pmt.cons(meta, out_vec)\n\n                self.message_port_pub(\n                    pmt.intern(\"out\"),\n                    out_pdu,\n                )\n\n                if self.verbose:\n                    confidence = float(np.mean(np.abs(final_llr)))\n\n                    print(\n                        f\"[VDE-TER Turbo Decoder] \"\n                        f\"Link ID {self.LinkID}, \"\n                        f\"mode={mode}, \"\n                        f\"iterations={self.iterations}, \"\n                        f\"{len(received)} -> {len(decoded)} bits, \"\n                        f\"mean |LLR|={confidence:.3f}\"\n                    )\n\n            except Exception as exc:\n                print(f\"[VDE-TER Turbo Decoder ERROR] {exc}\")\n\n\n# =============================================================================\n# Standalone self-test\n# =============================================================================\n\ndef _self_test() -> None:\n    \"\"\"\n    같은 폴더의 vde_ter_turbo_encoder_link11.py를 사용해 검증.\n\n    Test A:\n        오류 없는 874-bit codeword -> 원본 432 bits 완전 복원\n\n    Test B:\n        874 coded bits 중 20개를 고정 seed로 뒤집음\n        -> Turbo decoder가 원본 432 bits를 복원하는지 확인\n\n    주의:\n        Turbo Code가 임의의 20 bit 오류를 항상 보장해서 고친다는 뜻은 아니다.\n        이 self-test는 encoder/decoder 연결 및 기본 오류정정 동작 확인용이다.\n    \"\"\"\n    import importlib.util\n    from pathlib import Path\n\n    encoder_path = Path(__file__).with_name(\n        \"vde_ter_turbo_encoder_link11.py\"\n    )\n\n    if not encoder_path.exists():\n        print(\n            \"[SKIP] Encoder file not found next to decoder; \"\n            \"decoder module itself was loaded successfully.\"\n        )\n        return\n\n    spec = importlib.util.spec_from_file_location(\n        \"vde_encoder_for_test\",\n        str(encoder_path),\n    )\n    encoder = importlib.util.module_from_spec(spec)\n    spec.loader.exec_module(encoder)\n\n    rng = np.random.default_rng(20260810)\n\n    original = rng.integers(\n        0, 2, size=432, dtype=np.uint8\n    ).tolist()\n\n    encoded = encoder.turbo_encode(original, 11)\n\n    # Test A: no channel error\n    decoded, _ = turbo_decode(\n        encoded,\n        link_id=11,\n        iterations=6,\n        hard_input=True,\n        hard_llr=2.0,\n    )\n\n    errors = int(\n        np.count_nonzero(\n            np.asarray(decoded, dtype=np.uint8)\n            != np.asarray(original, dtype=np.uint8)\n        )\n    )\n\n    assert errors == 0\n\n    print(\"[PASS] Test A: no-error decode\")\n    print(\"       874 coded bits -> 432 original bits\")\n    print(\"       decoded bit errors = 0\")\n\n    # Test B: deterministic 20 coded-bit flips\n    corrupted = np.asarray(\n        encoded,\n        dtype=np.uint8,\n    )\n\n    flip_positions = rng.choice(\n        len(corrupted),\n        size=20,\n        replace=False,\n    )\n\n    corrupted[flip_positions] ^= 1\n\n    decoded_corrupt, _ = turbo_decode(\n        corrupted.tolist(),\n        link_id=11,\n        iterations=6,\n        hard_input=True,\n        hard_llr=2.0,\n    )\n\n    residual_errors = int(\n        np.count_nonzero(\n            np.asarray(decoded_corrupt, dtype=np.uint8)\n            != np.asarray(original, dtype=np.uint8)\n        )\n    )\n\n    assert residual_errors == 0\n\n    print(\"[PASS] Test B: 20 coded-bit flips corrected\")\n    print(\"       inserted channel bit errors = 20\")\n    print(\"       decoded bit errors          = 0\")\n\n\nif __name__ == \"__main__\":\n    _self_test()\n\n"
    hard_llr: '2.0'
    iterations: '6'
    verbose: 'True'
  states: {}
- name: epy_block_2
  id: epy_block
  parameters:
    _source_code: |
      #!/usr/bin/env python3
      # -*- coding: utf-8 -*-
      """
      VDE-TER Test Harness: Tag Original Bits
      ========================================
      Turbo Encoder에 들어가기 '직전'에 붙여서 사용.

      역할:
          입력 PDU의 데이터(원본 432bit)를 메타데이터에 'original' 키로 복사해 저장.
          데이터 자체는 그대로 통과시킴(인코더 입력은 안 건드림).

      이 메타데이터는 Encoder/Decoder를 거쳐도 그대로 보존되므로(두 블록 모두
      car(meta)를 안 건드리고 그대로 out_pdu에 다시 씀), 최종 Decoder 출력에서
      meta['original']을 꺼내 디코딩 결과와 대조할 수 있다.

      Message input port  : "in"
      Message output port : "out"
      """

      from __future__ import annotations

      try:
          import pmt
          from gnuradio import gr
          _GNURADIO_AVAILABLE = True
      except ImportError:
          pmt = None
          gr = None
          _GNURADIO_AVAILABLE = False


      def tag_original(meta_dict: dict, data: list) -> dict:
          """meta_dict에 'original' 키로 data의 복사본을 추가한 새 dict를 반환."""
          new_meta = dict(meta_dict) if meta_dict else {}
          new_meta['original'] = list(data)
          return new_meta


      if _GNURADIO_AVAILABLE:

          class blk(gr.basic_block):
              """VDE-TER Tag Original Bits (PDU passthrough + 원본 태깅)"""

              def __init__(self, verbose=False):
                  gr.basic_block.__init__(
                      self,
                      name="VDE-TER Tag Original",
                      in_sig=None,
                      out_sig=None,
                  )
                  self.verbose = bool(verbose)
                  self.message_port_register_in(pmt.intern("in"))
                  self.message_port_register_out(pmt.intern("out"))
                  self.set_msg_handler(pmt.intern("in"), self._handle_pdu)

              def _handle_pdu(self, msg):
                  try:
                      if not pmt.is_pair(msg):
                          raise ValueError("Input must be a PDU pair.")

                      meta = pmt.car(msg)
                      data = pmt.cdr(msg)

                      if not pmt.is_u8vector(data):
                          raise ValueError("PDU payload must be a u8vector.")

                      bits = list(pmt.u8vector_elements(data))

                      # meta(dict pmt)에 original 키 추가
                      new_meta = pmt.make_dict()
                      if pmt.is_dict(meta):
                          # 기존 meta 항목 보존
                          keys = pmt.dict_keys(meta)
                          for i in range(pmt.length(keys)):
                              k = pmt.nth(i, keys)
                              v = pmt.dict_ref(meta, k, pmt.PMT_NIL)
                              new_meta = pmt.dict_add(new_meta, k, v)

                      original_vec = pmt.init_u8vector(len(bits), bits)
                      new_meta = pmt.dict_add(new_meta, pmt.intern("original"), original_vec)

                      out_pdu = pmt.cons(new_meta, data)
                      self.message_port_pub(pmt.intern("out"), out_pdu)

                      if self.verbose:
                          print(f"[VDE-TER Tag Original] tagged {len(bits)} original bits")

                  except Exception as exc:
                      print(f"[VDE-TER Tag Original ERROR] {exc}")


      def _self_test():
          meta = {}
          data = [0, 1, 1, 0, 1]
          new_meta = tag_original(meta, data)
          assert new_meta['original'] == data
          print("[PASS] Tag Original self-test")


      if __name__ == "__main__":
          _self_test()
    verbose: 'True'
  states: {}
- name: epy_block_3
  id: epy_block
  parameters:
    _source_code: |
      #!/usr/bin/env python3
      # -*- coding: utf-8 -*-
      """
      VDE-TER Test Harness: Error Injector
      =====================================
      Turbo Encoder와 Turbo Decoder '사이'에 끼워서 사용.

      역할:
          입력 PDU(874bit 코드워드)에서 N개 비트를 무작위로 반전(flip)시켜
          "채널을 통과하며 오류가 생긴 상황"을 흉내낸다.
          메타데이터는 그대로 통과(원본 태그 보존).

      Message input port  : "in"
      Message output port : "out"
      """

      from __future__ import annotations
      import random

      try:
          import pmt
          from gnuradio import gr
          _GNURADIO_AVAILABLE = True
      except ImportError:
          pmt = None
          gr = None
          _GNURADIO_AVAILABLE = False


      def inject_errors(bits: list, n_flips: int, seed=None) -> tuple:
          """bits(list of 0/1) 중 n_flips개를 무작위로 뒤집는다. (뒤집힌 리스트, 위치목록) 반환."""
          rng = random.Random(seed)
          n_flips = min(n_flips, len(bits))
          positions = rng.sample(range(len(bits)), n_flips)
          out = list(bits)
          for p in positions:
              out[p] = 1 - out[p]
          return out, positions


      if _GNURADIO_AVAILABLE:

          class blk(gr.basic_block):
              """VDE-TER Error Injector (PDU bit-flip)"""

              def __init__(self, n_flips=5, seed=-1, verbose=False):
                  gr.basic_block.__init__(
                      self,
                      name="VDE-TER Error Injector",
                      in_sig=None,
                      out_sig=None,
                  )
                  self.n_flips = int(n_flips)
                  self.seed = None if int(seed) < 0 else int(seed)
                  self.verbose = bool(verbose)
                  self.message_port_register_in(pmt.intern("in"))
                  self.message_port_register_out(pmt.intern("out"))
                  self.set_msg_handler(pmt.intern("in"), self._handle_pdu)

              def _handle_pdu(self, msg):
                  try:
                      if not pmt.is_pair(msg):
                          raise ValueError("Input must be a PDU pair.")

                      meta = pmt.car(msg)
                      data = pmt.cdr(msg)

                      if not pmt.is_u8vector(data):
                          raise ValueError("PDU payload must be a u8vector.")

                      bits = list(pmt.u8vector_elements(data))
                      corrupted, positions = inject_errors(bits, self.n_flips, self.seed)

                      out_vec = pmt.init_u8vector(len(corrupted), corrupted)
                      out_pdu = pmt.cons(meta, out_vec)
                      self.message_port_pub(pmt.intern("out"), out_pdu)

                      if self.verbose:
                          print(f"[VDE-TER Error Injector] flipped {self.n_flips} bits "
                                f"at positions {positions[:10]}{'...' if len(positions) > 10 else ''}")

                  except Exception as exc:
                      print(f"[VDE-TER Error Injector ERROR] {exc}")


      def _self_test():
          bits = [0] * 874
          corrupted, positions = inject_errors(bits, 5, seed=1)
          n_diff = sum(1 for a, b in zip(bits, corrupted) if a != b)
          assert n_diff == 5
          assert len(positions) == 5
          print("[PASS] Error Injector self-test:", n_diff, "bits flipped")


      if __name__ == "__main__":
          _self_test()
    n_flips: '70'
    seed: '-1'
    verbose: 'True'
  states: {}
- name: epy_block_4
  id: epy_block
  parameters:
    _source_code: |
      #!/usr/bin/env python3
      # -*- coding: utf-8 -*-
      """
      VDE-TER Test Harness: Compare
      ===============================
      Turbo Decoder '뒤'에 붙여서 사용 (파이프라인 맨 끝).

      역할:
          입력 PDU의 meta에서 'original'(Tag Original 블록이 심어둔 원본 432bit)을 꺼내고,
          data(디코더가 복원한 432bit)와 비교해서 몇 bit가 다른지, 성공/실패인지 콘솔에 출력.

      Message input port : "in"
      (출력 포트 없음 - 최종 종단 블록)
      """

      from __future__ import annotations

      try:
          import pmt
          from gnuradio import gr
          _GNURADIO_AVAILABLE = True
      except ImportError:
          pmt = None
          gr = None
          _GNURADIO_AVAILABLE = False


      def compare_bits(original: list, decoded: list) -> tuple:
          """(다른 bit 개수, 성공여부) 반환"""
          if len(original) != len(decoded):
              return -1, False
          n_diff = sum(1 for a, b in zip(original, decoded) if a != b)
          return n_diff, (n_diff == 0)


      if _GNURADIO_AVAILABLE:

          class blk(gr.basic_block):
              """VDE-TER Compare (원본 vs 디코딩 결과 대조, 종단 블록)"""

              def __init__(self, verbose=True):
                  gr.basic_block.__init__(
                      self,
                      name="VDE-TER Compare",
                      in_sig=None,
                      out_sig=None,
                  )
                  self.verbose = bool(verbose)
                  self.message_port_register_in(pmt.intern("in"))
                  self.set_msg_handler(pmt.intern("in"), self._handle_pdu)

              def _handle_pdu(self, msg):
                  try:
                      if not pmt.is_pair(msg):
                          raise ValueError("Input must be a PDU pair.")

                      meta = pmt.car(msg)
                      data = pmt.cdr(msg)

                      if not pmt.is_u8vector(data):
                          raise ValueError("PDU payload must be a u8vector.")

                      decoded = list(pmt.u8vector_elements(data))

                      orig_pmt = pmt.dict_ref(meta, pmt.intern("original"), pmt.PMT_NIL)
                      if pmt.eqv(orig_pmt, pmt.PMT_NIL):
                          print("[VDE-TER Compare ERROR] meta에 'original' 키가 없음 "
                                "(Tag Original 블록을 인코더 앞에 연결했는지 확인)")
                          return
                      original = list(pmt.u8vector_elements(orig_pmt))

                      n_diff, success = compare_bits(original, decoded)

                      print("=" * 50)
                      print(f"[VDE-TER Compare] original={len(original)}bit, "
                            f"decoded={len(decoded)}bit")
                      print(f"  다른 bit 수 : {n_diff}")
                      print(f"  결과        : {'SUCCESS (완전 복원)' if success else 'FAIL (오류 잔존)'}")
                      print("=" * 50)

                  except Exception as exc:
                      print(f"[VDE-TER Compare ERROR] {exc}")


      def _self_test():
          original = [0, 1, 1, 0, 1]
          decoded_ok = [0, 1, 1, 0, 1]
          decoded_bad = [0, 1, 0, 0, 1]

          n_diff, ok = compare_bits(original, decoded_ok)
          assert n_diff == 0 and ok

          n_diff, ok = compare_bits(original, decoded_bad)
          assert n_diff == 1 and not ok

          print("[PASS] Compare self-test")


      if __name__ == "__main__":
          _self_test()
    verbose: 'True'
  states: {}
- name: pdu_tagged_stream_to_pdu_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: '"packet_len"'
    type: byte
  states: {}

connections:
- [analog_random_source_x_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', pdu_tagged_stream_to_pdu_0, '0']
- [epy_block_0, out, epy_block_3, in]
- [epy_block_1, out, epy_block_4, in]
- [epy_block_2, out, epy_block_0, in]
- [epy_block_3, out, epy_block_1, in]
- [pdu_tagged_stream_to_pdu_0, pdus, epy_block_2, in]

metadata:
  file_format: 1
  grc_version: 3.10.12.0
