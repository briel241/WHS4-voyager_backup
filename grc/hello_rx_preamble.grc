options:
  parameters:
    author: voyager_3
    description: Hello BPSK receiver with F9 A8 preamble
    generate_options: qt_gui
    id: hello_rx_preamble
    output_language: python
    title: Hello BPSK Receiver - F9 A8 Preamble
  states: {}

blocks:
- name: bpsk
  id: variable_constellation
  parameters:
    comment: BPSK 성상도 — 송수신이 같은 것을 써야 한다
    const_points: '[-1, 1]'
    precision: '8'
    rot_sym: '2'
    sym_map: '[0, 1]'
    type: bpsk
  states: {}
- name: center_freq
  id: variable
  parameters:
    comment: 1e9 로 바꿔도 되지만 주파수 오차가 8배 커진다
    value: 157.2e6
  states: {}
- name: excess_bw
  id: variable
  parameters:
    comment: RRC 롤오프
    value: '0.35'
  states: {}
- name: rx_dev
  id: variable
  parameters:
    comment: 수신 장비
    value: '''type=b200'''
  states: {}
- name: rx_gain
  id: variable
  parameters:
    value: '40'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    comment: 샘플레이트
    value: 1e6
  states: {}
- name: sps
  id: variable
  parameters:
    comment: 심볼당 샘플 -> 심볼률 250 ksym/s
    value: '4'
  states: {}
- name: const_view
  id: qtgui_const_sink_x
  parameters:
    autoscale: 'True'
    comment: 잠기면 좌우 두 덩어리로 모인다
    grid: 'True'
    name: 성상도 (BPSK = 점 2개면 잠긴 것)
    size: '1024'
    tr_tag: ''
    type: complex
    update_time: '0.1'
  states: {}
- name: costas
  id: digital_costas_loop_cc
  parameters:
    comment: 반송파 위상/주파수 오차 보정 (BPSK 는 order 2)
    order: '2'
    w: '0.0628'
  states: {}
- name: decoder
  id: digital_constellation_decoder_cb
  parameters:
    comment: 심볼 -> 비트 (바이트당 1비트)
    constellation: bpsk
  states: {}
- name: diff_dec
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    comment: 송신의 차동 부호화를 되돌린다 (BPSK 180도 모호성 해소)
    modulus: '2'
  states: {}
- name: preamble_correlator
  id: digital_correlate_access_code_tag_xx
  parameters:
    access_code: '''1111100110101000'''
    comment: Exact F9 A8 preamble detector; tag is placed on the first payload bit
    tagname: '''preamble_detected'''
    threshold: '0'
    type: byte
  states: {}
- name: payload_console
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      import pmt
      from gnuradio import gr


      class blk(gr.sync_block):
          """Print a fixed-size payload beginning at each preamble tag."""

          def __init__(self, tag_name='preamble_detected', payload_bytes=5):
              gr.sync_block.__init__(
                  self,
                  name='Preamble Payload Console',
                  in_sig=[np.uint8],
                  out_sig=None,
              )
              self.tag_name = tag_name
              self.payload_bytes = int(payload_bytes)
              self._tag_key = pmt.intern(tag_name)
              self._collecting = False
              self._payload_bits = []

          def work(self, input_items, output_items):
              data = input_items[0]
              start = self.nitems_read(0)
              stop = start + len(data)
              tags = self.get_tags_in_range(0, start, stop, self._tag_key)
              tag_offsets = {int(tag.offset - start) for tag in tags}

              for index, value in enumerate(data):
                  if index in tag_offsets:
                      self._collecting = True
                      self._payload_bits = []

                  if not self._collecting:
                      continue

                  self._payload_bits.append(int(value) & 1)
                  required_bits = self.payload_bytes * 8
                  if len(self._payload_bits) == required_bits:
                      payload = bytearray()
                      for offset in range(0, required_bits, 8):
                          byte = 0
                          for bit in self._payload_bits[offset:offset + 8]:
                              byte = (byte << 1) | bit
                          payload.append(byte)

                      message = bytes(payload).decode('utf-8', errors='replace')
                      print(f'Decoded message: {message}', flush=True)
                      self._collecting = False
                      self._payload_bits = []

              return len(data)
    comment: Collects the five payload bytes following each preamble and prints them
    payload_bytes: '5'
    tag_name: '''preamble_detected'''
  states: {}
- name: matched
  id: root_raised_cosine_filter
  parameters:
    alpha: excess_bw
    comment: 정합필터 — 송신과 같은 RRC
    decim: '1'
    gain: '1.0'
    ntaps: 11*sps+1
    samp_rate: samp_rate
    sym_rate: samp_rate/sps
    type: fir_filter_ccf
  states: {}
- name: readme
  id: note
  parameters:
    note: |-
      BPSK Hello receiver with preamble framing (Node B)

      RRC Filter    : receive-side matched filter
      Symbol Sync   : selects the symbol sampling instant
      Costas Loop   : corrects carrier frequency and phase error
      Const Decoder : converts BPSK symbols to one-bit bytes
      Diff Decoder  : removes differential coding and BPSK phase ambiguity
      Preamble      : exact MSB-first match for 0xF9 0xA8
      Console       : prints the five payload bytes following each preamble

      Output format: Decoded message: <five-byte UTF-8 payload>
      No decoded data is written to a file.
  states: {}
- name: rx_spectrum
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    average: '0.2'
    bw: samp_rate
    comment: ★ 디버깅 1순위 — 봉우리가 안 보이면 TX Gain 부터 올린다
    fc: '0'
    fftsize: '2048'
    grid: 'True'
    name: 수신 스펙트럼 (신호가 오는지 먼저 여기서 확인)
    tr_tag: ''
    type: complex
    update_time: '0.1'
    ymax: '-20'
  states: {}
- name: sym_sync
  id: digital_symbol_sync_xx
  parameters:
    comment: 심볼 시점 맞추기
    constellation: bpsk
    damping: '1.0'
    loop_bw: '0.045'
    max_dev: '1.5'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_MUELLER_AND_MULLER
    type: cc
  states: {}
- name: usrp_source
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    center_freq0: center_freq
    comment: AGC 끔 — 신호가 약할 때 잡음을 물고 올라가는 것을 막는다
    dev_addr: rx_dev
    gain0: rx_gain
    rx_agc0: Disabled
    samp_rate: samp_rate
    start_time: '-1'
    sync: sync
    type: fc32
  states: {}

connections:
- [costas, '0', const_view, '0']
- [costas, '0', decoder, '0']
- [decoder, '0', diff_dec, '0']
- [diff_dec, '0', preamble_correlator, '0']
- [matched, '0', sym_sync, '0']
- [preamble_correlator, '0', payload_console, '0']
- [sym_sync, '0', costas, '0']
- [usrp_source, '0', matched, '0']
- [usrp_source, '0', rx_spectrum, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
