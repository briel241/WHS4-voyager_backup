options:
  parameters:
    author: voyager_3
    description: Hello BPSK 송신 (Node A)
    generate_options: qt_gui
    id: hello_tx
    output_language: python
    title: Hello BPSK 송신 (Node A)
  states: {}

blocks:
- name: bpsk
  id: variable_constellation
  parameters:
    comment: BPSK 성상도 — 송수신이 같은 것을 써야 한다
    const_points: '[-1, 1]'
    precision: '8'
    rot_sym: '2'
    sym_map: '[0, 1]'
    type: bpsk
  states: {}
- name: center_freq
  id: variable
  parameters:
    comment: 1e9 로 바꿔도 되지만 주파수 오차가 8배 커진다
    value: 157.2e6
  states: {}
- name: excess_bw
  id: variable
  parameters:
    comment: RRC 롤오프
    value: '0.35'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    comment: 샘플레이트
    value: 1e6
  states: {}
- name: sps
  id: variable
  parameters:
    comment: 심볼당 샘플 -> 심볼률 250 ksym/s
    value: '4'
  states: {}
- name: tx_ampl
  id: variable
  parameters:
    comment: DAC 풀스케일 대비
    value: '0.5'
  states: {}
- name: tx_dev
  id: variable
  parameters:
    comment: 송신 장비
    value: '''serial=34D6357'''
  states: {}
- name: tx_gain
  id: variable
  parameters:
    comment: ★ 안 되면 여기부터 올린다 (0 은 최소값)
    value: '20'
  states: {}
- name: amp
  id: blocks_multiply_const_vxx
  parameters:
    const: tx_ampl
    type: complex
  states: {}
- name: hello_src
  id: blocks_vector_source_x
  parameters:
    comment: '''Hello'' 의 아스키 값. 계속 반복 송신한다'
    repeat: 'True'
    type: byte
    vector: '[72, 101, 108, 108, 111]'
  states: {}
- name: import_os
  id: import
  parameters:
    imports: import os
  states: {}
- name: modulator
  id: digital_constellation_modulator
  parameters:
    comment: 바이트를 MSB first 로 풀어 BPSK 로 싣고 RRC 성형까지 한다
    constellation: bpsk
    differential: 'True'
    excess_bw: excess_bw
    samples_per_symbol: sps
  states: {}
- name: readme
  id: note
  parameters:
    note: |-
      BPSK Hello 송신 (Node A)   -   링크 점검용, VDE-TER 규격과 무관
      Vector Source  : Hello 의 아스키 코드를 무한 반복 Const Modulator: 바이트를 비트로 풀고(MSB first) 차동부호화 후 BPSK+RRC Multiply Const : 디지털 단 진폭 조절 USRP Sink      : RF 송신
      안 되면 tx_gain 을 20 -> 30 -> 40 으로 올릴 것 (0 은 최소값) ★ 안테나 없이 동축 + 30dB 감쇠기 경로에서만 실행
      수신측: hello_rx.grc / 확인: tools/find_pattern.py ~/hello_rx.bin 자세한 설명: docs/hello_bpsk_check.md
  states: {}
- name: tx_spectrum
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    average: '0.2'
    bw: samp_rate
    comment: 송신 파형 확인용
    fc: '0'
    fftsize: '2048'
    grid: 'True'
    name: 송신 스펙트럼
    tr_tag: ''
    type: complex
    update_time: '0.1'
  states: {}
- name: usrp_sink
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    center_freq0: center_freq
    comment: ★ 안테나 없이 동축+감쇠기 경로에서만 실행할 것
    dev_addr: tx_dev
    gain0: tx_gain
    len_tag_name: ''
    samp_rate: samp_rate
    start_time: '-1'
    sync: sync
    type: fc32
  states: {}

connections:
- [amp, '0', tx_spectrum, '0']
- [amp, '0', usrp_sink, '0']
- [hello_src, '0', modulator, '0']
- [modulator, '0', amp, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
